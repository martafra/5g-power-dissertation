options:
  parameters:
    description: ZMQ broker for srsRAN gNB + srsUE (single UE)
    id: zmq_broker_1ue
    output_language: python
    title: ZMQ Broker - 1 UE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: zeromq_req_source_dl
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    comment: Receive DL from gNB
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_dl
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    comment: Send DL to UE
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_ul
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    comment: Receive UL from UE
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ul
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    comment: Send UL to gNB
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_req_source_dl, '0', zeromq_rep_sink_dl, '0']
- [zeromq_req_source_ul, '0', zeromq_rep_sink_ul, '0']

metadata:
  file_format: 1
  grc_version: 3.10.1.1
